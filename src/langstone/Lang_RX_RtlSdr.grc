options:
  parameters:
    generate_options: no_gui
    id: Lang_RX_RtlSdr
    output_language: python
  states: {}

blocks:
- name: AFGain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: FFT_SEL
  id: variable
  parameters:
    value: '0'
  states: {}
- name: RxOffset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: Rx_Filt_High
  id: variable
  parameters:
    value: '3000'
  states: {}
- name: Rx_Filt_Low
  id: variable
  parameters:
    value: '300'
  states: {}
- name: Rx_Gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: Rx_LO
  id: variable
  parameters:
    value: '1000000000'
  states: {}
- name: Rx_Mode
  id: variable
  parameters:
    value: '3'
  states: {}
- name: Rx_Mute
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-2'
    decay_rate: '5e-7'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '1000'
    reference: '0.1'
    type: complex
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '48000'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: '"hw:CARD=Device,DEV=0"'
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: Rx_Filt_High
    low_cutoff_freq: Rx_Filt_Low
    samp_rate: '48000'
    type: fir_filter_ccc
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: (AFGain/100.0) *  (not Rx_Mute)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: Rx_Mode<4
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (Rx_Mode==4) * 0.2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_1
  id: blocks_multiply_const_vxx
  parameters:
    const: Rx_Mode==5
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0 + (Rx_Mode==5)
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: FFT_SEL
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '7373'
    psize: '1472'
    type: float
    vlen: '512'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: RxOffset
    decim: '11'
    samp_rate: '528000'
    taps: firdes.low_pass(1,529200,23000,2000)
    type: ccc
  states: {}
- name: logpwrfft_x_0_1
  id: logpwrfft_x
  parameters:
    average: 'True'
    avg_alpha: '0.9'
    fft_size: '512'
    frame_rate: '15'
    ref_scale: '2'
    sample_rate: 48000/ (2 ** FFT_SEL)
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3000'
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_1
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: Rx_LO
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: '2000000'
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc3_xx_0, '0', blocks_complex_to_real_0_0, '0']
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_2_0, '0']
- [band_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [band_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [band_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [blocks_add_xx_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_add_xx_1_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_2_1, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_complex_to_real_0_0, '0', blocks_multiply_const_vxx_2_1_0, '0']
- [blocks_float_to_complex_0, '0', analog_agc3_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_add_xx_1_0, '0']
- [blocks_multiply_const_vxx_2_0, '0', blocks_add_xx_1, '1']
- [blocks_multiply_const_vxx_2_1, '0', blocks_add_xx_1_0, '1']
- [blocks_multiply_const_vxx_2_1_0, '0', blocks_add_xx_1, '0']
- [blocks_selector_0, '0', logpwrfft_x_0_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', band_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_selector_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_1_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_1_1, '0']
- [logpwrfft_x_0_1, '0', blocks_udp_sink_0, '0']
- [low_pass_filter_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_1, '0', blocks_selector_0, '1']
- [rational_resampler_xxx_1_0, '0', blocks_selector_0, '2']
- [rational_resampler_xxx_1_1, '0', blocks_selector_0, '3']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
